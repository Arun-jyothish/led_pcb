File: led_50w/_autosave-led_50w.kicad_sch (KiCad schematic)
At the start: 49 parts

Commit message: manual route layout issue
Parts:
- gave numbers to parts that had none: 49
